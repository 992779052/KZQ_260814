# Keil uVision project jad_kzq.uvprojx, settings and files
target jad_kzq (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F427VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: KZQ_260725 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: GD32F427,USE_USB_FS
  c include: ..\CMSIS;..\Startup;..\Library\GD32F4xx_standard_peripheral\Include;..\User;..\HeaderFiles;..\Implement;..\HardWare\LED;..\HardWare\KEY;..\Protocol\USART0;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\Tasks;..\HardWare;..\Middlewares\FATFS\exfuns;..\Middlewares\FATFS\source;..\Middlewares\USB\USB_APP;..\Middlewares\USB\GD32F4xx_usb_library\driver\Source;..\Middlewares\USB\GD32F4xx_usb_library\host;..\Middlewares\USB\GD32F4xx_usb_library\host\core\Include;..\Middlewares\USB\GD32F4xx_usb_library\driver\Include;..\Middlewares\USB\GD32F4xx_usb_library\host\class\msc\Include;..\Middlewares\USB\GD32F4xx_usb_library\ustd\class\msc;..\Middlewares\USB\GD32F4xx_usb_library\ustd\common;..\Middlewares\MALLOC;..\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c SPIOption.c
    ../FreeRTOS/: FreeRTOSConfig.h
  group HardWare
    ../HardWare/: GPIO.c CAN.c CH450IF.C lcd.c W25QXX.c RTC.c
  group Protocol
    ../Protocol/USART0/: USART0.c
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h
  group System
    ../System/: sys.c
  group CMSIS
    ../CMSIS/: system_gd32f4xx.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../Startup/: startup_gd32f407_427.s
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group Readme
    ../Readme/: Readme.txt
  group TaskDefine
    ../Tasks/: TaskDefine.c
  group Middlewares/MALLOC
    ../Middlewares/MALLOC/: malloc.c
  group Middlewares/FATFS
    ../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c
    ../Middlewares/FATFS/exfuns/: exfuns.c fattester.c myffunicode.c
  group Middlewares/USB_Drives
    ../Middlewares/USB/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_host.c drv_usbh_int.c
  group Middlewares/USB_Host
    ../Middlewares/USB/GD32F4xx_usb_library/host/core/Source/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group Middlewares/USB_Class
    ../Middlewares/USB/GD32F4xx_usb_library/host/class/msc/Source/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group Middlewares/USB_APP
    ../Middlewares/USB/USB_APP/: usbh_hw.c usbh_usr.c
